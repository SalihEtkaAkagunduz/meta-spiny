FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://busybox.cfg"