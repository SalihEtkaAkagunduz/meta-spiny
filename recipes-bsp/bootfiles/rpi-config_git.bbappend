FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://lcd-35.txt \
    file://cmdline.txt \
"

do_deploy:append() {
    # Ensure deploy directory exists
    install -d ${DEPLOYDIR}/bcm2835-bootfiles
    
    # Deploy cmdline.txt from meta-spiny
    if [ -f ${WORKDIR}/cmdline.txt ]; then
        install -m 0644 ${WORKDIR}/cmdline.txt ${DEPLOYDIR}/bcm2835-bootfiles/
        bbnote "Installed cmdline.txt with LCD console support"
    else
        bbwarn "cmdline.txt not found in WORKDIR"
    fi
    
    # Check if parent recipe created config.txt
    if [ -f ${DEPLOYDIR}/bcm2835-bootfiles/config.txt ]; then
        # NOTE: LCD configuration disabled - using HDMI only
        # If you want LCD support, uncomment the lines below
        
        # Disable VC4 KMS (conflicts with fbtft driver)
        # sed -i 's/^dtoverlay=vc4-kms-v3d/#dtoverlay=vc4-kms-v3d # Disabled for LCD compatibility/' ${DEPLOYDIR}/bcm2835-bootfiles/config.txt
        
        # Append LCD 3.5" configuration to config.txt
        # echo "" >> ${DEPLOYDIR}/bcm2835-bootfiles/config.txt
        # cat ${WORKDIR}/lcd-35.txt >> ${DEPLOYDIR}/bcm2835-bootfiles/config.txt
        
        # For HDMI-only: ensure VC4 KMS is enabled
        if ! grep -q "^dtoverlay=vc4-kms-v3d" ${DEPLOYDIR}/bcm2835-bootfiles/config.txt; then
            echo "" >> ${DEPLOYDIR}/bcm2835-bootfiles/config.txt
            echo "# HDMI Display (VC4 KMS)" >> ${DEPLOYDIR}/bcm2835-bootfiles/config.txt
            echo "dtoverlay=vc4-kms-v3d" >> ${DEPLOYDIR}/bcm2835-bootfiles/config.txt
        fi
    else
        # Parent recipe hasn't created config.txt yet, create base version
        bbwarn "config.txt not found in parent recipe output, creating minimal config"
        cat > ${DEPLOYDIR}/bcm2835-bootfiles/config.txt << 'EOF'
# Minimal Raspberry Pi config.txt
# Generated by rpi-config bbappend
enable_uart=1
arm_64bit=1
EOF
        # Append LCD configuration
        echo "" >> ${DEPLOYDIR}/bcm2835-bootfiles/config.txt
        cat ${WORKDIR}/lcd-35.txt >> ${DEPLOYDIR}/bcm2835-bootfiles/config.txt
    fi
}
